# Keil uVision project modbus_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: modbus_test +hex
  c flags: Optimize=5 SizeSpeed=1
  group Source Group 1
    ./: system.c main.c modbusRTU.c DS18B20.c
