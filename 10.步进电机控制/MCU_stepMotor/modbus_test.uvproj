# Keil uVision project modbus_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: modbus_test +hex
  c flags: Optimize=5 SizeSpeed=1
  group Source Group 1
    ./: system.c main.c modbusRTU.c
